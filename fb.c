/* fb.c — pixel/rect/text drawing layer implementation. See fb.h for the
 * API contract.
 *
 * Freestanding: only <stdint.h> and "fb.h". No libc, no floats. Every fill
 * is a manual pixel/word loop (never memset/memcpy) so nothing pulls in a
 * libgcc/NEON helper under -mgeneral-regs-only.
 *
 * Pixel format: 32-bit 0xAARRGGBB (matches DE2's XRGB8888 UI-layer format
 * in hdmi.c — the alpha byte is written through untouched, the display
 * engine ignores it for an opaque full-screen layer).
 */
#include <stdint.h>
#include "fb.h"

/* ---- geometry sanity limits (reject implausible fb_init calls) -------- */
#define FB_MIN_DIM 1
#define FB_MAX_DIM 8192

/* ------------------------------------------------------------------ */
/* 8x8 monospace ASCII font, printable range 0x20..0x7E (95 glyphs).    */
/* Classic public-domain "PC/VGA 8x8" bitmap set (same shapes as widely */
/* used bare-metal/OSDev 8x8 fonts). One byte per row, bit x = column x */
/* (bit0 = leftmost pixel, bit7 = rightmost). Index: (c - 0x20) * 8.     */
/* ------------------------------------------------------------------ */
static const uint8_t font[95 * FB_FONT_H] = {
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /* 0x20 ' ' */
	0x18, 0x3C, 0x3C, 0x18, 0x18, 0x00, 0x18, 0x00, /* 0x21 '!' */
	0x36, 0x36, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /* 0x22 '"' */
	0x36, 0x36, 0x7F, 0x36, 0x7F, 0x36, 0x36, 0x00, /* 0x23 '#' */
	0x0C, 0x3E, 0x03, 0x1E, 0x30, 0x1F, 0x0C, 0x00, /* 0x24 '$' */
	0x00, 0x63, 0x33, 0x18, 0x0C, 0x66, 0x63, 0x00, /* 0x25 '%' */
	0x1C, 0x36, 0x1C, 0x6E, 0x3B, 0x33, 0x6E, 0x00, /* 0x26 '&' */
	0x06, 0x06, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, /* 0x27 ''' */
	0x18, 0x0C, 0x06, 0x06, 0x06, 0x0C, 0x18, 0x00, /* 0x28 '(' */
	0x06, 0x0C, 0x18, 0x18, 0x18, 0x0C, 0x06, 0x00, /* 0x29 ')' */
	0x00, 0x66, 0x3C, 0xFF, 0x3C, 0x66, 0x00, 0x00, /* 0x2A '*' */
	0x00, 0x0C, 0x0C, 0x3F, 0x0C, 0x0C, 0x00, 0x00, /* 0x2B '+' */
	0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x0C, 0x06, /* 0x2C ',' */
	0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, /* 0x2D '-' */
	0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x0C, 0x00, /* 0x2E '.' */
	0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x00, /* 0x2F '/' */
	0x3E, 0x63, 0x73, 0x7B, 0x6F, 0x67, 0x3E, 0x00, /* 0x30 '0' */
	0x0C, 0x0E, 0x0C, 0x0C, 0x0C, 0x0C, 0x3F, 0x00, /* 0x31 '1' */
	0x1E, 0x33, 0x30, 0x1C, 0x06, 0x33, 0x3F, 0x00, /* 0x32 '2' */
	0x1E, 0x33, 0x30, 0x1C, 0x30, 0x33, 0x1E, 0x00, /* 0x33 '3' */
	0x38, 0x3C, 0x36, 0x33, 0x7F, 0x30, 0x78, 0x00, /* 0x34 '4' */
	0x3F, 0x03, 0x1F, 0x30, 0x30, 0x33, 0x1E, 0x00, /* 0x35 '5' */
	0x1C, 0x06, 0x03, 0x1F, 0x33, 0x33, 0x1E, 0x00, /* 0x36 '6' */
	0x3F, 0x33, 0x30, 0x18, 0x0C, 0x0C, 0x0C, 0x00, /* 0x37 '7' */
	0x1E, 0x33, 0x33, 0x1E, 0x33, 0x33, 0x1E, 0x00, /* 0x38 '8' */
	0x1E, 0x33, 0x33, 0x3E, 0x30, 0x18, 0x0E, 0x00, /* 0x39 '9' */
	0x00, 0x0C, 0x0C, 0x00, 0x00, 0x0C, 0x0C, 0x00, /* 0x3A ':' */
	0x00, 0x0C, 0x0C, 0x00, 0x00, 0x0C, 0x0C, 0x06, /* 0x3B ';' */
	0x18, 0x0C, 0x06, 0x03, 0x06, 0x0C, 0x18, 0x00, /* 0x3C '<' */
	0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, /* 0x3D '=' */
	0x06, 0x0C, 0x18, 0x30, 0x18, 0x0C, 0x06, 0x00, /* 0x3E '>' */
	0x1E, 0x33, 0x30, 0x18, 0x0C, 0x00, 0x0C, 0x00, /* 0x3F '?' */
	0x3E, 0x63, 0x7B, 0x7B, 0x7B, 0x03, 0x1E, 0x00, /* 0x40 '@' */
	0x0C, 0x1E, 0x33, 0x33, 0x3F, 0x33, 0x33, 0x00, /* 0x41 'A' */
	0x3F, 0x66, 0x66, 0x3E, 0x66, 0x66, 0x3F, 0x00, /* 0x42 'B' */
	0x3C, 0x66, 0x03, 0x03, 0x03, 0x66, 0x3C, 0x00, /* 0x43 'C' */
	0x1F, 0x36, 0x66, 0x66, 0x66, 0x36, 0x1F, 0x00, /* 0x44 'D' */
	0x7F, 0x46, 0x16, 0x1E, 0x16, 0x46, 0x7F, 0x00, /* 0x45 'E' */
	0x7F, 0x46, 0x16, 0x1E, 0x16, 0x06, 0x0F, 0x00, /* 0x46 'F' */
	0x3C, 0x66, 0x03, 0x03, 0x73, 0x66, 0x7C, 0x00, /* 0x47 'G' */
	0x33, 0x33, 0x33, 0x3F, 0x33, 0x33, 0x33, 0x00, /* 0x48 'H' */
	0x1E, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x1E, 0x00, /* 0x49 'I' */
	0x78, 0x30, 0x30, 0x30, 0x33, 0x33, 0x1E, 0x00, /* 0x4A 'J' */
	0x67, 0x66, 0x36, 0x1E, 0x36, 0x66, 0x67, 0x00, /* 0x4B 'K' */
	0x0F, 0x06, 0x06, 0x06, 0x46, 0x66, 0x7F, 0x00, /* 0x4C 'L' */
	0x63, 0x77, 0x7F, 0x7F, 0x6B, 0x63, 0x63, 0x00, /* 0x4D 'M' */
	0x63, 0x67, 0x6F, 0x7B, 0x73, 0x63, 0x63, 0x00, /* 0x4E 'N' */
	0x1C, 0x36, 0x63, 0x63, 0x63, 0x36, 0x1C, 0x00, /* 0x4F 'O' */
	0x3F, 0x66, 0x66, 0x3E, 0x06, 0x06, 0x0F, 0x00, /* 0x50 'P' */
	0x1E, 0x33, 0x33, 0x33, 0x3B, 0x1E, 0x38, 0x00, /* 0x51 'Q' */
	0x3F, 0x66, 0x66, 0x3E, 0x36, 0x66, 0x67, 0x00, /* 0x52 'R' */
	0x1E, 0x33, 0x07, 0x0E, 0x38, 0x33, 0x1E, 0x00, /* 0x53 'S' */
	0x3F, 0x2D, 0x0C, 0x0C, 0x0C, 0x0C, 0x1E, 0x00, /* 0x54 'T' */
	0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x3F, 0x00, /* 0x55 'U' */
	0x33, 0x33, 0x33, 0x33, 0x33, 0x1E, 0x0C, 0x00, /* 0x56 'V' */
	0x63, 0x63, 0x63, 0x6B, 0x7F, 0x77, 0x63, 0x00, /* 0x57 'W' */
	0x63, 0x63, 0x36, 0x1C, 0x1C, 0x36, 0x63, 0x00, /* 0x58 'X' */
	0x33, 0x33, 0x33, 0x1E, 0x0C, 0x0C, 0x1E, 0x00, /* 0x59 'Y' */
	0x7F, 0x63, 0x31, 0x18, 0x4C, 0x66, 0x7F, 0x00, /* 0x5A 'Z' */
	0x1E, 0x06, 0x06, 0x06, 0x06, 0x06, 0x1E, 0x00, /* 0x5B '[' */
	0x03, 0x06, 0x0C, 0x18, 0x30, 0x60, 0x40, 0x00, /* 0x5C '\' */
	0x1E, 0x18, 0x18, 0x18, 0x18, 0x18, 0x1E, 0x00, /* 0x5D ']' */
	0x08, 0x1C, 0x36, 0x63, 0x00, 0x00, 0x00, 0x00, /* 0x5E '^' */
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, /* 0x5F '_' */
	0x0C, 0x0C, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, /* 0x60 '`' */
	0x00, 0x00, 0x1E, 0x30, 0x3E, 0x33, 0x6E, 0x00, /* 0x61 'a' */
	0x07, 0x06, 0x06, 0x3E, 0x66, 0x66, 0x3B, 0x00, /* 0x62 'b' */
	0x00, 0x00, 0x1E, 0x33, 0x03, 0x33, 0x1E, 0x00, /* 0x63 'c' */
	0x38, 0x30, 0x30, 0x3E, 0x33, 0x33, 0x6E, 0x00, /* 0x64 'd' */
	0x00, 0x00, 0x1E, 0x33, 0x3F, 0x03, 0x1E, 0x00, /* 0x65 'e' */
	0x1C, 0x36, 0x06, 0x0F, 0x06, 0x06, 0x0F, 0x00, /* 0x66 'f' */
	0x00, 0x00, 0x6E, 0x33, 0x33, 0x3E, 0x30, 0x1F, /* 0x67 'g' */
	0x07, 0x06, 0x36, 0x6E, 0x66, 0x66, 0x67, 0x00, /* 0x68 'h' */
	0x0C, 0x00, 0x0E, 0x0C, 0x0C, 0x0C, 0x1E, 0x00, /* 0x69 'i' */
	0x30, 0x00, 0x30, 0x30, 0x30, 0x33, 0x33, 0x1E, /* 0x6A 'j' */
	0x07, 0x06, 0x66, 0x36, 0x1E, 0x36, 0x67, 0x00, /* 0x6B 'k' */
	0x0E, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x1E, 0x00, /* 0x6C 'l' */
	0x00, 0x00, 0x33, 0x7F, 0x7F, 0x6B, 0x63, 0x00, /* 0x6D 'm' */
	0x00, 0x00, 0x1F, 0x33, 0x33, 0x33, 0x33, 0x00, /* 0x6E 'n' */
	0x00, 0x00, 0x1E, 0x33, 0x33, 0x33, 0x1E, 0x00, /* 0x6F 'o' */
	0x00, 0x00, 0x3B, 0x66, 0x66, 0x3E, 0x06, 0x0F, /* 0x70 'p' */
	0x00, 0x00, 0x6E, 0x33, 0x33, 0x3E, 0x30, 0x78, /* 0x71 'q' */
	0x00, 0x00, 0x3B, 0x6E, 0x66, 0x06, 0x0F, 0x00, /* 0x72 'r' */
	0x00, 0x00, 0x3E, 0x03, 0x1E, 0x30, 0x1F, 0x00, /* 0x73 's' */
	0x08, 0x0C, 0x3E, 0x0C, 0x0C, 0x2C, 0x18, 0x00, /* 0x74 't' */
	0x00, 0x00, 0x33, 0x33, 0x33, 0x33, 0x6E, 0x00, /* 0x75 'u' */
	0x00, 0x00, 0x33, 0x33, 0x33, 0x1E, 0x0C, 0x00, /* 0x76 'v' */
	0x00, 0x00, 0x63, 0x6B, 0x7F, 0x7F, 0x36, 0x00, /* 0x77 'w' */
	0x00, 0x00, 0x63, 0x36, 0x1C, 0x36, 0x63, 0x00, /* 0x78 'x' */
	0x00, 0x00, 0x33, 0x33, 0x33, 0x3E, 0x30, 0x1F, /* 0x79 'y' */
	0x00, 0x00, 0x3F, 0x19, 0x0C, 0x26, 0x3F, 0x00, /* 0x7A 'z' */
	0x38, 0x0C, 0x0C, 0x07, 0x0C, 0x0C, 0x38, 0x00, /* 0x7B '{' */
	0x18, 0x18, 0x18, 0x00, 0x18, 0x18, 0x18, 0x00, /* 0x7C '|' */
	0x07, 0x0C, 0x0C, 0x38, 0x0C, 0x0C, 0x07, 0x00, /* 0x7D '}' */
	0x6E, 0x3B, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /* 0x7E '~' */
};

/* ------------------------------------------------------------------ */
/* Surface state                                                       */
/* ------------------------------------------------------------------ */
static volatile uint32_t *g_base;
static int g_width, g_height, g_stride;
static int g_ready;

/* Dirty pixel-row range [g_dirty_y0, g_dirty_y1] (inclusive) accumulated
 * since the last fb_flush(); g_dirty_y0 < 0 means "nothing dirty". */
static int g_dirty_y0 = -1;
static int g_dirty_y1 = -1;

static void mark_dirty(int y0, int y1)
{
	if (y0 < 0)
		y0 = 0;
	if (y1 >= g_height)
		y1 = g_height - 1;
	if (y1 < y0)
		return;

	if (g_dirty_y0 < 0 || y0 < g_dirty_y0)
		g_dirty_y0 = y0;
	if (y1 > g_dirty_y1)
		g_dirty_y1 = y1;
}

void fb_init(uint32_t *base, int w, int h, int stride)
{
	g_ready = 0;

	if (base == (uint32_t *)0)
		return;
	if (w < FB_MIN_DIM || w > FB_MAX_DIM)
		return;
	if (h < FB_MIN_DIM || h > FB_MAX_DIM)
		return;
	if (stride < w || stride > FB_MAX_DIM)
		return;

	g_base = (volatile uint32_t *)base;
	g_width = w;
	g_height = h;
	g_stride = stride;

	g_dirty_y0 = -1;
	g_dirty_y1 = -1;

	g_ready = 1;
}

int fb_ready(void)
{
	return g_ready;
}

void fb_pixel(int x, int y, uint32_t argb)
{
	if (!g_ready)
		return;
	if ((unsigned)x >= (unsigned)g_width || (unsigned)y >= (unsigned)g_height)
		return;

	g_base[(int64_t)y * g_stride + x] = argb;
	mark_dirty(y, y);
}

void fb_clear(uint32_t argb)
{
	int x, y;

	if (!g_ready)
		return;

	for (y = 0; y < g_height; y++) {
		volatile uint32_t *row = &g_base[(int64_t)y * g_stride];
		for (x = 0; x < g_width; x++)
			row[x] = argb;
	}

	mark_dirty(0, g_height - 1);
}

void fb_fillrect(int x, int y, int w, int h, uint32_t argb)
{
	int x0, y0, x1, y1, xx, yy;

	if (!g_ready || w <= 0 || h <= 0)
		return;

	x0 = x;
	y0 = y;
	x1 = x + w; /* exclusive */
	y1 = y + h;

	if (x0 < 0)
		x0 = 0;
	if (y0 < 0)
		y0 = 0;
	if (x1 > g_width)
		x1 = g_width;
	if (y1 > g_height)
		y1 = g_height;
	if (x0 >= x1 || y0 >= y1)
		return;

	for (yy = y0; yy < y1; yy++) {
		volatile uint32_t *row = &g_base[(int64_t)yy * g_stride];
		for (xx = x0; xx < x1; xx++)
			row[xx] = argb;
	}

	mark_dirty(y0, y1 - 1);
}

void fb_rect(int x, int y, int w, int h, uint32_t argb)
{
	if (!g_ready || w <= 0 || h <= 0)
		return;

	fb_fillrect(x, y, w, 1, argb);              /* top */
	fb_fillrect(x, y + h - 1, w, 1, argb);       /* bottom */
	fb_fillrect(x, y, 1, h, argb);               /* left */
	fb_fillrect(x + w - 1, y, 1, h, argb);       /* right */
}

void fb_char(int x, int y, char c, uint32_t fg, uint32_t bg)
{
	const uint8_t *bitmap;
	unsigned char ch = (unsigned char)c;
	int row, col;

	if (!g_ready)
		return;

	if (ch >= 0x20 && ch <= 0x7E)
		bitmap = &font[(unsigned)(ch - 0x20) * FB_FONT_H];
	else
		bitmap = (const uint8_t *)0;

	for (row = 0; row < FB_FONT_H; row++) {
		uint8_t bits = bitmap ? bitmap[row] : 0;

		for (col = 0; col < FB_FONT_W; col++)
			fb_pixel(x + col, y + row,
				 (bits & (1u << col)) ? fg : bg);
	}
}

void fb_str(int x, int y, const char *s, uint32_t fg, uint32_t bg)
{
	int cx = x;

	if (!g_ready || !s)
		return;

	while (*s) {
		fb_char(cx, y, *s, fg, bg);
		cx += FB_FONT_W;
		s++;
	}
}

void fb_hex(int x, int y, uint64_t v, int ndigits, uint32_t fg, uint32_t bg)
{
	static const char hexdig[16] = "0123456789ABCDEF";
	int i;
	int cx = x;

	if (!g_ready)
		return;
	if (ndigits < 1)
		ndigits = 1;
	if (ndigits > 16)
		ndigits = 16;

	for (i = ndigits - 1; i >= 0; i--) {
		uint32_t nib = (uint32_t)((v >> (i * 4)) & 0xFu);
		fb_char(cx, y, hexdig[nib], fg, bg);
		cx += FB_FONT_W;
	}
}

int fb_dec(int x, int y, uint64_t v, uint32_t fg, uint32_t bg)
{
	char digits[20];
	int n = 0;
	int i;
	int cx = x;

	if (!g_ready)
		return 0;

	if (v == 0) {
		digits[n++] = '0';
	} else {
		while (v > 0 && n < (int)sizeof(digits)) {
			digits[n++] = (char)('0' + (int)(v % 10u));
			v /= 10u;
		}
	}

	/* digits[] was filled least-significant-first; draw MS-first. */
	for (i = n - 1; i >= 0; i--) {
		fb_char(cx, y, digits[i], fg, bg);
		cx += FB_FONT_W;
	}

	return n;
}

void fb_flush(void)
{
	uint64_t ctr, line, start, end, addr;

	__asm__ volatile("dsb sy" ::: "memory");

	if (!g_ready || g_dirty_y0 < 0 || g_dirty_y1 < g_dirty_y0) {
		g_dirty_y0 = -1;
		g_dirty_y1 = -1;
		return;
	}

	/* CTR_EL0.DminLine (bits[19:16]): log2 of the smallest data cache
	 * line, in 4-byte words. line_bytes = 4 << DminLine (64 bytes on
	 * Cortex-A53, the A64's core). */
	__asm__ volatile("mrs %0, ctr_el0" : "=r"(ctr));
	line = (uint64_t)4 << ((ctr >> 16) & 0xFu);
	if (line == 0)
		line = 64;

	start = (uint64_t)(uintptr_t)&g_base[(int64_t)g_dirty_y0 * g_stride];
	end = (uint64_t)(uintptr_t)&g_base[(int64_t)(g_dirty_y1 + 1) * g_stride];

	start &= ~(line - 1);
	end = (end + line - 1) & ~(line - 1);

	for (addr = start; addr < end; addr += line)
		__asm__ volatile("dc civac, %0" : : "r"(addr) : "memory");

	__asm__ volatile("dsb sy" ::: "memory");

	g_dirty_y0 = -1;
	g_dirty_y1 = -1;
}
